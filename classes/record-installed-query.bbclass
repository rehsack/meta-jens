#
# This is to query recorded installed key-apps without putting entire package
# database on target
#

inherit record-installed-common
