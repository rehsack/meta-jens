#
# This helps to register & track recorded installed key-apps without putting
# entire package database on target
#

RECORD_INSTALLED_DEST ??= "/opt/record-installed"
