# Copyright (C) 2018 Jens Rehsack <sno@netbsd.org>
# Released under the MIT license (see COPYING.MIT for the terms)

PACKAGECONFIG ??= ""

require wine-native.inc
